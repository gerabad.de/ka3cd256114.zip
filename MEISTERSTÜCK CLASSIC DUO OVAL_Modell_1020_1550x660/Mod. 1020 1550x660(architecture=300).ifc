Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_87/temp/tmp_5536_71_siXmt/format_2/Mod. 1020 1550x660 FertRoh(architecture=300).ifc
Time: 2025-09-03T09:27:30
Made in: PARTsolutions

# IfcDiscreteAccessory, Mod. 1020 1550x660 FertRoh(architecture=300)
In: BUILDING
Description: Mod. 1020 1550x660 FertRoh(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: Mod. 1020 1550x660 FertRoh
ePset_PARTsolutions - NB: Mod. 1020 1550x660 FertRoh(architecture=300); NN: Mod. 1020 1550x660 FertRoh; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: Mod. 1020 1550x660 FertRoh(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: Mod. 1020 1550x660 FertRoh; B: mod_1020_1550x660_fertroh.png; E: KALDEWEI
